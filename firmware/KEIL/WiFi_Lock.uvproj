# Keil uVision project WiFi_Lock.uvproj, settings and files
target WiFi_Lock (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: M0516LDN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: WiFi_Lock +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HAL_ASSERT_RESET, BLINK_LEDS, HAL_LED = TRUE
  c include: ..\M051BSPv3\Library\CMSIS\Include;..\M051BSPv3\Library\Device\Nuvoton\M051Series\Include;..\M051BSPv3\Library\StdDriver\inc;..\..\trunk;..\osal;..\hal;..\app;..\hci;..\lib;..\heap
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../M051BSPv3/Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
    ../M051BSPv3/Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group FwLib
    ../M051BSPv3/Library/StdDriver/src/: acmp.c adc.c clk.c ebi.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group APP
    ../App/: main.c
    ../app/: app_lock.c websocket.c
  group HCI
    ../hci/: hci_wifi.c hci_wificmd.c hci_wifiatcop.c
  group HAL
    ../Hal/: hal_interrupt.c hal_uart.c
    ../hal/: hal_drivers.c hal_terminal.c hal_assert.c hal_led.c hal_key.c hal_devid.c hal_flash.c hal_atcmdsio.c hal_buzzer.c
  group LIB
    ../lib/: stringx.c md5.c
  group OSAL
    ../osal/: osal.c osal_memory.c osal_tasks.c osal_clock.c osal_timers.c osal_bufmgr.c osal_pwrmgr.c osal_cbtimer.c osal_fifo.c
  group HEAP
    ../heap/: umm_info.c umm_integrity.c umm_malloc.c umm_poison.c
